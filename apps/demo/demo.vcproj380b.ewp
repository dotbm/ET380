# IAR project demo.vcproj380b.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK21FN1M0xxx12 Freescale MK21FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CPU_1903
  ICCARM.CCIncludePath2: ..\..\sdk\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: LCD_COLOR_1BIT
  OBJCOPY.OOCOutputFile: demo_80b.bin
  ILINK.IlinkOutputFile: dev.out
  ILINK.IlinkIcfFile: settings\et380_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group lib
    ../../sdk/lib/: apppub2.a atc.a iot.a json.a libapi_xpos.a mbedtls.a mqtt_embed.a net.a productTest.a pub.a rpc.a tms.a wifi.a
    ../../sdk/driver/libet380-p2/: ET380-P2_HAL.a FATFS.a FLASH_FAL.a IAR6_MH1903_MSR.a UCOSII.a
  group src
    src/: http_sync.c main.c mainpage.c mqtt_wrapper.c player_proc.c
